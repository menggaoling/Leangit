<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>BootLoader</name>
    <group>
      <name>Boot</name>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Boot.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Boot_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\BOOT_stm32f10x_md.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\BOOT_stm32f10x_md_vl.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Bootflash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Bootuart.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
      </file>
    </group>
    <group>
      <name>Loader</name>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Loader.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Loader_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Loader_ivector.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Loader_ivector_md.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\LoaderUART.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>LCB</name>
    <group>
      <name>API</name>
      <group>
        <name>CSTARTUP</name>
        <group>
          <name>Libraries</name>
          <group>
            <name>STM32F10x_StdPeriph_Driver</name>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\LCB\src\ADC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\LCB\src\LCB_stm32f10x_md.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\LCB\src\LCB_stm32f10x_md_vl.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BootAPI\LowLevelInitial\manual_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BootAPI\src\system_stm32f10x.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\LCB\src\EEPROM.C</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\EMControl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\JHTLCBComm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\LCBMain.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\Mx25L1606E.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\RPM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\LCB\src\Table.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Link</name>
    <file>
      <name>$PROJ_DIR$\Link\JHT_LCB-BV1.0.icf</name>
    </file>
  </group>
</project>


