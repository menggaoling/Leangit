# IAR project 2013_1xLCB.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: BootAPI\inc\; LCB\inc\; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\CMSIS\CM3\CoreSupport\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 1xBikeLCB_V2.002.bin
  ILINK.IlinkOutputFile: 2013_1xLCB.out
  ILINK.IlinkIcfFile: Link\JHT_LCB-BV1.0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BootLoader/Boot
    BootAPI/src/: Boot.c Boot_it.c BOOT_stm32f10x_md.s BOOT_stm32f10x_md_vl.s Bootflash.c Bootuart.c
  group BootLoader/CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group BootLoader/Loader
    BootAPI/src/: Loader.c Loader_it.c Loader_ivector.s Loader_ivector_md.s LoaderUART.c
  group LCB/API
    LCB/src/: EEPROM.C EMControl.c JHTLCBComm.c LCBMain.c Mx25L1606E.c RPM.c stm32f10x_it.c Table.c
  group LCB/API/CSTARTUP
    LCB/src/: ADC.c LCB_stm32f10x_md.s LCB_stm32f10x_md_vl.s
    BootAPI/LowLevelInitial/: manual_init.c
    BootAPI/src/: system_stm32f10x.c
  group LCB/API/CSTARTUP/Libraries/STM32F10x_StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Link
    Link/: JHT_LCB-BV1.0.icf
